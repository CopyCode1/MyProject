/* 仅供负向编译验证：故意偏离授权区域，必须被BUILD_ASSERT拒绝。
 * 不得用于烧录；不会产生可用的自测固件。
 */
&flash_test_partition {
	reg = <0x00ffe000 0x00001000>;
};
